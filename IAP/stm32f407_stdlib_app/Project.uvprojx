# Keil uVision project Project.uvprojx, settings and files
target Temple (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: need_updata_fw +hex
  AfterMake: D:\Program Files\Soft\MDK\ARM\ARMCC\bin\fromelf.exe   --bin -o ./Out/need_updata_fw.bin ./Out/need_updata_fw.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: .\Libraries\inc;.\User;.\Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c sys.c io.c stmflash.c
  group Lib
    ./Libraries/src/: stm32f4xx_rcc.c misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group Sartup
    ./Libraries/: startup_stm32f4xx.s
software components: CMSIS:CORE 5.3.0
